# Keil uVision project KEA128.uvprojx, settings and files
target KEA128 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: SKEAZ128xxx4 Freescale
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(20000000) ELITTLE
  output: KEA128 +hex
  AfterMake: fromelf.exe --bin --output ./BIN/kea128.bin ./Output/*.axf
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TRK_KEA128   CPU_KEA128  KEIL
  c include: ..\Source\common;..\Source\platforms;..\Source\cpu;..\Source\Sch;..\Source\drivers\wdog;..\Source\drivers\sim;..\Source\drivers\rtc;..\Source\drivers\pit;..\Source\drivers\uart;..\Source\drivers\can;..\Source\drivers\adc;..\Source\cpu\headers;..\Source\drivers\gpio;..\Source\drivers\ftm;..\Source\drivers\nvm;..\Source\drivers\ics;..\Source\drivers\sim;..\Source\App;..\Source\TEF663X;..\Source\TW8836;..\Source\drivers\PMC
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group APP
    ../Source/App/: main.c bsp.c interrupt.c system.c task.c mw_uart.c app_arm.c mw_gpio.c mw_can.c mw_i2c.c mw_adc.c app_voltage.c app_updata.c mw_flash.c mw_rtc.c mw_time.c
  group Driver
    ../Source/cpu/: arm_cm0.c systick.c sysinit.c
    ../Source/drivers/wdog/: wdog.c
    ../Source/drivers/rtc/: rtc.c
    ../Source/drivers/pit/: pit.c
    ../Source/drivers/uart/: uart.c
    ../Source/drivers/can/: mscan.c
    ../Source/drivers/adc/: adc.c
    ../Source/drivers/gpio/: gpio.c
    ../Source/drivers/ftm/: ftm.c
    ../Source/drivers/nvm/: flash.c
    ../Source/drivers/ics/: ics.c
    ../Source/drivers/sim/: sim.c
    ../Source/drivers/PMC/: pmc.c
  group SCH
    ../Source/Sch/: sch_queue.c sch_common.c sch_message.c sch_printf.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
