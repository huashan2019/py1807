# Keil uVision project KEA128.uvprojx, settings and files
target KEA128 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: SKEAZ128xxx4 Freescale
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(20000000) ELITTLE
  output: KEA128 +hex
  AfterMake: fromelf.exe --bin --output ./BIN/kea128.bin ./Output/*.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TRK_KEA128   CPU_KEA128  KEIL
  c include: ..\Source\common;..\Source\platforms;..\Source\cpu;..\Source\Sch;..\Source\drivers\wdog;..\Source\drivers\sim;..\Source\drivers\rtc;..\Source\drivers\pit;..\Source\drivers\uart;..\Source\drivers\can;..\Source\drivers\adc;..\Source\cpu\headers;..\Source\drivers\gpio;..\Source\drivers\ftm;..\Source\drivers\nvm;..\Source\drivers\ics;..\Source\drivers\sim;..\Source\App;..\Source\drivers\PMC;..\Source\drivers\spi;..\Source\drivers\kbi
  memory RVCT4: ROM 0x4000 size 0x1c000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group APP
    ../Source/App/: main.c bsp.c interrupt.c system.c task.c app_mute.c mw_uart.c app_power.c mw_gpio.c mw_adc.c app_voltage.c app_updata.c mw_flash.c app_tdf8541.c app_lowpower.c app_amp.c app_bt.c app_dsp_adau1452.c app_eprom.c mw_spi.c mw_i2c.c app_arm.c app_ad1938.c app_debug.c app_start.c app_led.c app_at.c app_connect.c app_dspdata_access.c app_dsp_driver.c app_dsp_eq.c app_dsp_filter.c app_dsp_readback.c app_dsp_single_mute.c app_dsp_mix.c app_panel.c
  group Driver
    ../Source/cpu/: arm_cm0.c systick.c sysinit.c
    ../Source/drivers/wdog/: wdog.c
    ../Source/drivers/rtc/: rtc.c
    ../Source/drivers/pit/: pit.c
    ../Source/drivers/uart/: uart.c
    ../Source/drivers/can/: mscan.c
    ../Source/drivers/adc/: adc.c
    ../Source/drivers/gpio/: gpio.c
    ../Source/drivers/ftm/: ftm.c
    ../Source/drivers/nvm/: flash.c
    ../Source/drivers/ics/: ics.c
    ../Source/drivers/sim/: sim.c
    ../Source/drivers/PMC/: pmc.c
    ../Source/drivers/spi/: spi.c
    ../Source/drivers/kbi/: kbi.c
  group SCH
    ../Source/Sch/: sch_queue.c sch_common.c sch_message.c sch_printf.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
